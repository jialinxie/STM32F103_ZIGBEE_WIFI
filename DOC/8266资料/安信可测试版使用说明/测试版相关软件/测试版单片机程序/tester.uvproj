# Keil uVision project tester.uvproj, settings and files
target trster (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: tester
  c flags: Optimize=8 SizeSpeed=1
  group tester
    ./: tester.c
